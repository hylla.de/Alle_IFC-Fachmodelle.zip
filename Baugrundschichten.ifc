Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: rbfSBL geotechnisches IFC-Modell
File name: Baugrundschichten.ifc.tmp
Time: 2026-09-12T09:47:50+02:00
Author: rbfSBL
Organization: rbfSBL
Written by: rbfSBL
Made in: rbfSBL

# IfcProject: Geotechnical model, DGGT Beispiel – Vorgabe DGGT
Description: rbfSBL geotechnisches Modell – IFC 4.3 ADD2

# IfcSite: Geotechnical site, DGGT Beispiel – Vorgabe DGGT
Description: Projektstandort; LongName: DGGT Beispiel – Vorgabe DGGT

# IfcGeomodel: rbfSBL IfcGeomodel, DGGT Beispiel – Vorgabe DGGT – Baugrundmodell
Description: Volumetrisches geologisches und geotechnisches rbfSBL-Modell
Pset_Allgemeine_Projektinformationen - Projektname: Testprojekt-Fachmodell_Baugrund; Modellautor: z. B. Jörg Bauer; Fachautor: z. B. Jörg Bauer; Datum der Erstellung: z. B. 24.06.2021; Datum der letzten Änderung: z. B. 07.07.2021; Entwicklungsstufe: Genehmigungsplanung; Koordinatensystem_Lage: Koordinatensystem_Lage: lokal; Lage_Status: ETRS89 / UTM zone 32N; Koordinatensystem_Höhe: DHHN2016; EPSG-Code_Koordinatensystem_Lage: -; EPSG-Code_Koordinatensystem_Höhe: 7837; Geotechnische Kategorie: GK3; Geotechnische Kategorie: Vorschrift: DIN 4020:2010-12; Erdbebenzone: 0; Erdbeben Baugrundklasse: C; Erdbeben Untergrundklasse: R; Erdbebengefährdung: Vorschrift: DIN EN 1998-1:2010-12 / DIN EN 1998-1/A1:2013-05; Höhensystem_Status: DHHN2016 / mNHN
Pset_rbfSBL_ProjectInformation - ProjectName: DGGT Beispiel; ProjectNumber: DGGT-Testprojekt-26-08-31-IFC-Varianten; Responsible: Geonova; Author: Geonova; Organization: Geonova; ModelAuthor: Geonova; DisciplineAuthor: Geonova; Description: DGGT-Testprojekt mit mehreren IFC-/Property-Set-Datensätzen für SVG/HTML und IFC4X3_ADD2.; ProjectPhase: Genehmigungsplanung; CreationDate: 2026-09-12; ModifiedDate: 2026-09-12; CoordinateReferenceSystem: lokal; ETRS89 / UTM zone 32N; EPSG-Code nicht angegeben; HeightReferenceSystem: DHHN2016 / mNHN / EPSG:7837; Notes: Projektphase: Genehmigungsplanung DGGT-Testprojekt: 15 einzelne BKF/CPT als IfcBorehole mit Erkundungsattributen und SVG-Zuordnung angereichert.

# IfcGeotechnicalStratum: Geotechnical stratum (6)
PredefinedType: SOLID
Pset_rbfSBL_Geologie - Geometrieart: IfcTriangulatedFaceSet; GeschlosseneTeilkörper: 1; OffeneNetzkanten: 0; ReparierteTeilschalen: 0; Netzaufbau: geschlossenes gemeinsames Netz
Name | Description = Beschreibung | Einheitstyp | Typkenner | Kenner | Reihenfolge | Obergrenze | Untergrenze | Grenzflächenvariante | DGMAlsOberkante | UntersterAbschlussIstInterpretierteGrenze | GrenzeinheitenBeschneidung | RestkoerperIndex | DurchZusatzkoerperErsetzt | DreieckeGrundriss | DreieckeGesamt | Netzknoten | TechnischeAbschlussknoten | DirektVernetzteLinsenkörper | IFCAbschlusstoleranz_m | Modellvolumen | ProjizierteGrundflaeche | MinimaleMaechtigkeit (m) | MaximaleMaechtigkeit (m) | MittlereMaechtigkeit (m)
Auffüllung | Auffüllung | Schicht | S | S1 | 1 | OK_S1 | OK_S2 | z_safety (superponiert) | yes | yes | 0 | 1 | yes | 12190 | 25132 | 12568 | 0 | 0 | 0 | 18359.5 | 6000 | 1.48944 | 8.61814 | 3.05991 | Pset_Laborversuchsergebnisse_Boden_gemischtkörnig - Bezeichnung der Baugrundschicht: Auffüllung; Bodengruppe Erd-/Grundbau: GI, SI, GU, GU*, SU, SU*, UL; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 7; w_Boden_max: 25; w_Boden_mittel: 15.5; w_Boden: Anzahl Laborversuche: 12; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; Vgl_min: 2; Vgl_max: 5; Vgl_mittel: 3.5; Vgl: Anzahl Laborversuche: 6; Vgl: Vorschrift: DIN 18128:2002-12; Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 20.5; gamma_feucht_Boden_max: 22; gamma_unter_Wasserauftrieb_Boden_min: -; gamma_unter_Wasserauftrieb_Boden_max: -; gamma_wassergesaettigt_Boden_min: -; gamma_wassergesaettigt_Boden_max: -; phi_eff_min: 25; phi_eff_max: 29; E_S_Erstbel_min: 8 m; E_S_Erstbel_max: 10 m
Sand/Kies | Sand/Kies | Schicht | S | S2 | 2 | OK_S2 | OK_S3 | z_safety (superponiert) | no | yes | 2 | 1 | yes | 12190 | 25132 | 12568 | 0 | 0 | 0 | 65613.8 | 6000 | 9.36364 | 13.4054 | 10.9356 | Pset_Statische_Kennwerte_Boden_nichtbindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 20; gamma_unter_Wasserauftrieb_Boden_min: 9.5; gamma_unter_Wasserauftrieb_Boden_max: 11.5; gamma_wassergesaettigt_Boden_min: 19.5; gamma_wassergesaettigt_Boden_max: 21.5; phi_eff_min: 30; phi_eff_max: 31.5; E_S_Erstbel_max: 15 m; E_S_Erstbel_min: 12.5; Pset_Laborversuchsergebnisse_Boden_nichtbindig - Bezeichnung der Baugrundschicht: Sand/Kies; Bodengruppe Erd-/Grundbau: GW, GI, SW, SI, GU, GU*, SU, SU*; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 2; w_Boden_max: 6; w_Boden_mittel: 3.5; w_Boden: Anzahl Laborversuche: 7; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; V_Karbonat_Boden_min: 12; V_Karbonat_Boden_max: 47; V_Karbonat_Boden_mittel: 29; V_Karbonat_Boden: Anzahl Laborversuche: 11; V_Karbonat_Boden: Vorschrift: DIN 18129:2011-07
Lösslehm | Lösslehm | Schicht | S | S3 | 3 | OK_S3 | OK_S4 | z_safety (superponiert) | no | yes | 2 | 1 | yes | 12190 | 25132 | 12568 | 0 | 0 | 0 | 58079.9 | 6000 | 7.49684 | 11.5308 | 9.67998 | Pset_Laborversuchsergebnisse_Boden_bindig - Bezeichnung der Baugrundschicht: Lösslehm; Bodengruppe Erd-/Grundbau: TL, TM, TA; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 29; w_Boden_max: 68; w_Boden_mittel: 49.5; w_Boden: Anzahl Laborversuche: 24; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; I_P_min: 13.1; I_P_max: 34.2; I_P_mittel: 22.4; I_P: Anzahl Laborversuche: 9; I_P: Vorschrift: DIN EN ISO 17892-12:2020-07; Pset_Statische_Kennwerte_Boden_bindig - gamma_feucht_Boden_min: 18.5; gamma_feucht_Boden_max: 21; gamma_unter_Wasserauftrieb_Boden_min: 9; gamma_unter_Wasserauftrieb_Boden_max: 11; gamma_wassergesaettigt_Boden_min: 19; gamma_wassergesaettigt_Boden_max: 21; phi_eff_min: 21; phi_eff_max: 24.5; E_S_Erstbel_min: 5 m; E_S_Erstbel_max: 7 m
Sand- und Schluffstein | Sand- und Schluffstein | Schicht | S | S4 | 4 | OK_S4 | Modellunterkante (Darstellungsabschluss) | z_safety (superponiert) | no | no | 0 | 1 | yes | 12190 | 25132 | 12568 | 0 | 0 | 0 | 40480.6 | 6000 | 3.79021 | 8.4154 | 6.74676 | Pset_Laborversuchsergebnisse_Fels - Bezeichnung der Felsschicht: Sand- und Schluffstein; Genetische Einheit: sedimentär; Genetische Einheit: Vorschrift: DIN EN ISO 14689:2018-05; sigma_u_min: 45 m; sigma_u_max: 92 m; sigma_u_mittel: 65.5; sigma_u: Anzahl Laborversuche: 18; sigma_u: Vorschrift: Empfehlung Nr. 1 des AK 3.3 der DGGT:2004-10; Verwitterung und Veränderungen_von: teilweise verfärbt; Verwitterung und Veränderungen_bis: leicht zerfallen; Verwitterung und Veränderungen: Vorschrift: DIN EN ISO 14689:2018-05; Pset_Statische_Kennwerte_Fels - gamma_feucht_Fels_min: 22.5; gamma_feucht_Fels_max: 25; ny_Erstbel_min: 0.2; ny_Erstbel_max: 0.3; E_Erstbel_min: 10000 m; E_Erstbel_max: 15000 m
Schluff-Grenzlinse (auskeilende Zwischenschicht) | Schluff-Grenzlinse (auskeilende Zwischenschicht) | Grenzlinse | GL | G1 |  |  |  |  |  |  |  |  |  | 4960 | 10240 | 5122 | 160 | 1 | 0.000001 | 757.046 | 555.655 | 0.000001 | 2.1 | 1.36244 | Pset_Laborversuchsergebnisse_Boden_bindig - Bezeichnung der Baugrundschicht: Schluff; Bodengruppe Erd-/Grundbau: UL; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 35; w_Boden_max: 54; w_Boden_mittel: 46.5; w_Boden: Anzahl Laborversuche: 4; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; I_P_min: 4.2; I_P_max: 6.4; I_P_mittel: 4.5; I_P: Anzahl Laborversuche: 4; I_P: Vorschrift: DIN EN ISO 17892-12:2020-07; Pset_Statische_Kennwerte_Boden_bindig - gamma_feucht_Boden_min: 17.5; gamma_feucht_Boden_max: 19; gamma_unter_Wasserauftrieb_Boden_min: 9; gamma_unter_Wasserauftrieb_Boden_max: 10; gamma_wassergesaettigt_Boden_min: 19; gamma_wassergesaettigt_Boden_max: 20; phi_eff_min: 25; phi_eff_max: 27.5; E_S_Erstbel_min: 2 m; E_S_Erstbel_max: 4 m; Pset_rbfSBL_Geologie - Instanz: 2; Entstehungsfolge: 5; ZulaessigeSchichten: S2, S3; Reichweite_m: 16.5; RangeLokal_m: 5; OffsetLokal_m: 0; OffsetLokalAktiv: yes; OffsetLokalGespeichert_m: 0; Endform: abgerundet; Grundrissform: elliptisch; WirksameGrundrissform: elliptisch; Mittelpunktmodus: Stützstelle; Linsenverteilung: ein Körper; Zufallsbereich: abgeleiteter Einflussbereich; Koerperrolle: Einzellinse; ZusaetzlicheZufallslinse: no; ZusaetzlicheLinsenAnzahl: 1; ZufallsbreiteMin_m: 1.98; ZufallsbreiteMax_m: 14.85; ZufallshoeheMin_m: 1.05; ZufallshoeheMax_m: 2.6; Koerperbreite_m: 33; MaximaleMaechtigkeit_m: 2.1; Pflichtvorkommen: yes; NullnachweisQuelle: no; TeilkörperIndex: 2; Stützstellenbindung: yes; Quellstützstelle: ST_BKF_7; Vorkommensindex: 1; Grundrissmittelpunkt: [48.4, 26.6]; AuskeilenderRand: yes; ÜberlagerungspunkteRaster: 0; BandueberschneidungenZulaessig: no
Schluff-Grenzlinse (auskeilende Zwischenschicht) | Schluff-Grenzlinse (auskeilende Zwischenschicht) | Grenzlinse | GL | G1 |  |  |  |  |  |  |  |  |  | 4960 | 10240 | 5122 | 49 | 1 | 0.000001 | 401.578 | 226.048 | 0.000001 | 2.6 | 1.77652 | Pset_Laborversuchsergebnisse_Boden_bindig - Bezeichnung der Baugrundschicht: Schluff; Bodengruppe Erd-/Grundbau: UL; Bodengruppe Erd-/Grundbau: Vorschrift: DIN 18196:2011-05; w_Boden_min: 35; w_Boden_max: 54; w_Boden_mittel: 46.5; w_Boden: Anzahl Laborversuche: 4; w_Boden: Vorschrift: DIN EN ISO 17892-1:2015-03; I_P_min: 4.2; I_P_max: 6.4; I_P_mittel: 4.5; I_P: Anzahl Laborversuche: 4; I_P: Vorschrift: DIN EN ISO 17892-12:2020-07; Pset_Statische_Kennwerte_Boden_bindig - gamma_feucht_Boden_min: 17.5; gamma_feucht_Boden_max: 19; gamma_unter_Wasserauftrieb_Boden_min: 9; gamma_unter_Wasserauftrieb_Boden_max: 10; gamma_wassergesaettigt_Boden_min: 19; gamma_wassergesaettigt_Boden_max: 20; phi_eff_min: 25; phi_eff_max: 27.5; E_S_Erstbel_min: 2 m; E_S_Erstbel_max: 4 m; Pset_rbfSBL_Geologie - Instanz: 1; Entstehungsfolge: 5; ZulaessigeSchichten: S2, S3; Reichweite_m: 16.5; RangeLokal_m: 5; OffsetLokal_m: 0; OffsetLokalAktiv: yes; OffsetLokalGespeichert_m: 0; Endform: abgerundet; Grundrissform: elliptisch; WirksameGrundrissform: elliptisch; Mittelpunktmodus: Stützstelle; Linsenverteilung: ein Körper; Zufallsbereich: abgeleiteter Einflussbereich; Koerperrolle: Einzellinse; ZusaetzlicheZufallslinse: no; ZusaetzlicheLinsenAnzahl: 1; ZufallsbreiteMin_m: 1.98; ZufallsbreiteMax_m: 14.85; ZufallshoeheMin_m: 1.05; ZufallshoeheMax_m: 2.6; Koerperbreite_m: 33; MaximaleMaechtigkeit_m: 2.6; Pflichtvorkommen: yes; NullnachweisQuelle: no; TeilkörperIndex: 1; Stützstellenbindung: yes; Quellstützstelle: ST_BKF_10; Vorkommensindex: 1; Grundrissmittelpunkt: [2.6, 1.5]; AuskeilenderRand: yes; ÜberlagerungspunkteRaster: 0; BandueberschneidungenZulaessig: no
